# Keil uVision project main.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM4\ARMCM4_ac6.sct
  group Source Group 1
    ./: main.s data.s module1_structGenerator.s module2_attendanceData.s module3_leaveManagement.s module4_overtimeCalculation.s module5_allowanceProcessor.s module6_taxComputation.s module7_netSalary.s module8_sortStruct.s module9_departmentalSalary.s module10_bonusCalculator.s module11_paySlip.s print.c
software components: CMSIS:CORE 6.1.1, Device:Startup 2.2.0
